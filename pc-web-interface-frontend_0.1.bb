SUMMARY = "A web interface frontend for the personal computer"
LICENSE = "MIT"
LIC_FILES_CHKSUM = 


